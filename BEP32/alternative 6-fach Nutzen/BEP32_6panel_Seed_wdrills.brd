# Repository marukitano/BEP3.0 (continued)

## EAGLE design BEP33/BEP33_12panel stencil.brd (continued)

Schematic: BEP33_12panel stencil.sch, sheet 10

Parts:
6V7, 10V7: TPSB2.0; B2.0
15, 16: 2081-1132; 12-PIN
C75, C76: 100u; C1206
C77, C84: 100nF,; C0805
C78, C85: 4.7u; C0805
C79, C80: 100nF.; C0805
C81: 2.2nF; C0805
C82, C83: 100nF; C0805
C86: 10u; C1206
D82, D83: 1N4007,; DO-214AC
D84, D89: 1N4007.; DO-214AC
D85, D88: 1N5817; DO-214AC_SLIM
D86, D87: 1N5817.; DO-214AC_SLIM
D90: 1N4007; DO-214AC
D91: Zen15; DO214AA
D92, D93: SS12; DO-214AC_SLIM
D94: Zen11; SOD-123_MINI-SMA
FID29, FID30, FID31, FID32: FIDUCIAL; FIDUCIAL_1MM
IC55: 4028; SO16
IC56: 317TO202H_NOHOLE; TO220H_NOHOLE
IC57: ULN2004; SO16
IC58: LM339; SO14
IC59: 78L06; SOT89_ROUND
IC60: 555; SO08
IC61: 4538; SO16
IC62: 78L10; SOT89_ROUND
IC63: LM2904; SO08
JP31, JP33, JP34, JP35: JP2EJP2_SMALLPADS; JP2_SMALLPADS
JP32: JP2E_ORIG; JP2_ORIG_SMALLPADS
LED37, LED38, LED39, LED40, LED41, LED42: LEDLD260; LD260
Q64, Q67, Q72: BA; SOT89
Q65, Q66: BA.; SOT89
Q68: MY; SOT89
Q69, Q70, Q71, Q73: J1; SOT-23
R358, R360, R387, R388: 47; V235/17_1MM
R359, R379, R380, R401, R404: 13; R1206
R361, R362, R363, R368, R369, R384, R385, R398, R399, R400, R406: 104; R0805
R364, R374, R382, R405: 4701; R0805
R365, R366, R371, R373, R391, R392, R395, R396: 1002; R0805
R367, R370: 1502; R0805
R372, R390, R402: 2201; R0805
R375, R381, R386, R389, R394: 2702; R0805
R376, R377, R378, R393: 102; R0805
R383, R403, R407, R408: 100; R0805
R397: R_user; R0805
SJMP7: SJ
START7: TPSB2.0; B2.0
TP162, TP163, TP164, TP165, TP166, TP167, TP168, TP169, TP170, TP171, TP172, TP173, TP174, TP175, TP176, TP177, TP178, TP179, TP181, TP182, TP183, TP184: TPSB2.0; B2.0
TP180: TPSB1,27; B1,27
X19: CON_BMWV2; 24-PIN_V2
X20: 22-23-2051
X21: 22-23-2021

Connections:
+10V: 10V7.TP, C82.1, IC60.4 (R), IC60.8 (V+), IC61.3 (CD), IC61.5 (B), IC61.13 (CD), IC61.16 (VDD), IC62.1 (OUT), R389.2, R406.2; also elsewhere on the board
+12V: 16.1, C86.1, D91.C, IC55.16 (VDD), IC57.9 (CD+), IC59.3 (IN), IC62.3 (IN), JP31.2, R361.2, R362.2, R363.2, R379.1, R380.1, R384.1, R407.2, R408.2, TP183.TP, X20.1; also elsewhere on the board
+12V8: 16.11, Q68.2 (C), R390.1, TP182.TP
GND: 15.12, C75.2, C76.2, C77.2, C78.2, C79.2, C80.1, C81.1, C82.2, C83.2, C84.2, C85.1, C86.2, D89.1 (+), D91.A, D94.A, IC55.8 (VSS), IC55.11 (D), IC57.8 (GND), IC58.12 (GND), IC59.2 (GND), IC59.2@1 (GND), IC60.1 (GND), IC61.1 (T1), IC61.8 (VSS), IC61.15 (T1), IC62.2 (GND), IC62.2@1 (GND), IC63.4 (V-), Q69.2 (S), Q71.2 (S), Q73.2 (S), R365.1, R371.1, R375.1, R376.2, R385.2, R387.1, R388.1, R396.1, R397.2, R401.2, R402.2, R403.1, X19.13, X19.18, X19.23, X20.5, X21.1; also elsewhere on the board
unnamed: R358.2, R360.1
unnamed: 16.9, D85.1 (+), D86.1 (+), JP33.1, JP34.2, TP180.TP
unnamed: IC55.10 (A), R363.1, R400.1, R400.2, X19.4, X20.2
unnamed: IC55.13 (B), R362.1, R399.1, R399.2, X19.3, X20.3
unnamed: D89.2 (-), Q64.2 (C), START7.TP, X19.5
unnamed: IC55.12 (C), R361.1, R398.1, R398.2, X19.2, X20.4
unnamed: 16.7, LED41.A, TP178.TP, X19.8
unnamed: 16.2, D87.2 (-), LED37.K (C), TP173.TP, X19.12
unnamed: 16.3, D86.2 (-), LED38.K (C), TP174.TP, X19.11
unnamed: 16.4, D85.2 (-), LED39.K (C), TP175.TP, X19.10
unnamed: 16.8, D88.2 (-), LED42.K (C), TP179.TP, X19.14
unnamed: 15.9, D82.1 (+), TP170.TP, X19.17
unnamed: 15.11, D83.1 (+), TP172.TP, X19.19
unnamed: R364.2, X19.22
unnamed: C78.1, IC63.3 (+IN), R364.1
unnamed: IC58.1 (OUT), R368.2, R373.2
unnamed: C75.1, R368.1, R369.2
unnamed: C76.1, IC58.4 (-IN), IC58.10 (-IN), R369.1
unnamed: IC58.5 (+IN), IC58.11 (+IN), R370.1, R371.2, R372.2
unnamed: C79.1, IC58.9 (+IN), R375.2, R381.2
unnamed: C80.2, IC58.14 (OUT), R374.2
unnamed: Q67.1 (B), R374.1
unnamed: IC55.2 (Q2), IC57.7 (I7)
unnamed: 15.5, IC57.12 (O5), TP166.TP
unnamed: IC55.1 (Q4), IC57.4 (I4)
unnamed: 16.10, TP181.TP, X19.15
unnamed: 16.5, D84.2 (-), LED40.K (C), TP176.TP, X19.9
unnamed: D84.1 (+), R358.1
unnamed: IC55.6 (Q5), IC57.3 (I3)
unnamed: 15.4, IC57.10 (O7), TP165.TP
unnamed: IC56.1 (ADJ), R359.1, R366.2, X19.7
unnamed: IC58.6 (-IN), IC58.8 (-IN), R366.1
unnamed: 15.2, Q66.2 (C), TP163.TP
unnamed: 15.1, D93.2 (-), TP162.TP
unnamed: R386.2, X19.16
unnamed: IC55.15 (Q3), IC57.5 (I5)
unnamed: 15.6, IC57.13 (O4), TP167.TP
unnamed: 15.7, IC57.14 (O3), TP168.TP
unnamed: 16.6, JP32.2, TP177.TP
unnamed: LED37.A, LED38.A, LED39.A, LED40.A, LED42.A
unnamed: Q64.1 (B), R378.2
unnamed: IC55.3 (Q0), IC57.1 (I1), IC57.2 (I2), Q70.1 (G), Q71.1 (G)
unnamed: IC55.14 (Q1), IC57.6 (I6)
unnamed: 15.3, IC57.11 (O6), TP164.TP
unnamed: Q65.1 (B), Q65.2 (C), Q66.1 (B), R376.1, R397.1, X21.2
unnamed: Q66.3 (E), R380.2
unnamed: Q65.3 (E), R379.2
unnamed: IC58.7 (+IN), R367.1, R381.1
unnamed: IC63.2 (-IN), R365.2
unnamed: Q68.1 (B), R382.2, R402.1
unnamed: Q69.3 (D), R383.2
unnamed: IC56.2 (VO), R359.2
unnamed: IC56.3 (VI), Q67.2 (C)
unnamed: IC60.3 (Q), IC61.4 (A), IC61.12 (A)
unnamed: D90.1 (+), R386.1
unnamed: 15.10, D82.2 (-), D83.2 (-), JP35.1, TP171.TP
unnamed: JP35.2, R387.2, R388.2
unnamed: IC61.9 (!Q), IC61.11 (B), R391.2
unnamed: C83.1, IC61.14 (T2), R389.1
unnamed: JP31.1, R390.2
unnamed: IC57.15 (O2), R378.1
unnamed: 16.12, R391.1, TP184.TP
unnamed: D87.1 (+), JP33.2
unnamed: IC63.1 (OUT), R392.2
unnamed: C84.1, R392.1, R393.1
unnamed: IC63.5 (+IN), Q71.3 (D), R393.2, R394.2
unnamed: IC63.6 (-IN), R395.1, R396.2
unnamed: D88.1 (+), JP34.1
unnamed: JP32.3, R383.1
unnamed: IC58.13 (OUT), JP32.1, Q69.1 (G), R384.2
unnamed: R377.1, X19.21
unnamed: IC57.16 (O1), Q70.3 (D), R404.1
unnamed: D92.2 (-), R407.1, R408.1
unnamed: 15.8, R404.2, TP169.TP
unnamed: Q70.2 (S), R403.2
unnamed: D93.1 (+), X19.1
unnamed: Q68.3 (E), R401.1
unnamed: C81.2, D90.2 (-), D94.C, IC60.2 (TR), IC60.6 (THR), R385.1
unnamed: Q72.1 (B), R405.1
unnamed: Q73.3 (D), R405.2
unnamed: Q72.2 (C), R360.2, SJMP7.2
unnamed: IC63.7 (OUT), R377.2, R382.1, R394.1
unnamed: IC58.2 (OUT), R372.1
unnamed: IC61.7 (!Q), Q73.1 (G)
unnamed: C85.2, IC61.2 (T2), R406.1
V+: D92.1 (+), Q64.3 (E), Q67.3 (E), Q72.3 (E), SJMP7.1, X19.6; also elsewhere on the board
VCC: 6V7.TP, C77.1, IC58.3 (V+), IC59.1 (OUT), IC63.8 (V+), R367.2, R370.2, R373.1, R395.2; also elsewhere on the board

Notes on the sheet:
6V regulated for Opamps
current source 96mA
ZündungsPlus
Zündugsplus Choke Öldrucklampe Temperaturlampe Ladekontrolllampe Tankgeber (100hm) ABS-Lampe Lampentest Warnlampe Fernlichtlampe Geschwindigkeitssignal Menütaster
DauerPlus Konstant-Strom für LEDs Gang 1 Gang 2 Gang 3 Gang 4 Gang 5 Neutrallampe Blinker rechts Blinker zusammen Blinker links Masse
DauerPlus Batterie 12V (rot weiss) Ganganzeige Signal C (gelb weiss) Ganganzeige Signal B (gelb schwarz) Ganganzeige Signal A (gelb dunkelblau) 12V/350mA zum Starknopf (schwarz grün) Zündungsplus 12V (grün schwarz) Reservelampe (weiss) ABS Leuchte (blau) Ladekontrollleuchte (schaltet auf Masse) (vi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
Masse (braun) Lampentest (schaltet auf Masse)(weiss blau) Fernlichtlampe (12V) (weiss) Drehzahl Zündspule (schwarz blau) Blinker rechts (blau scharz) Masse (braun) Blinker links (blau rot) nicht angeschlossen Tachosiganl zum Blinrelais (balu grün) Tachogeber (gelb) Masse Tachobeger (braun) Tachobel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
4.7V
Stromquelle für Gang LEDs. Für mehr als 12mA muss ein Widerstand "R_user" eingelötet werden. Für weniger muss der 1kOhm SMD Widerstand neben R_user entfernt werden I = 12V/1kOhm(default)+12V/R_user I= 12mA (default) + 12V/R_user Beispiel: R_user Strom in LEDs 1 kOhm 22-26mA ohne 11-13mA
Gang 1
Gang 2
Gang 3
Gang 4
Gang 5
Variante "eine LED leuchtet"
Variante "alle LEDs bis und mit Gang X leuchten"
Klemmleisten Ausgang:
Klemmleisten Ausgang:
an Zündungsplus anhängen (Neutral leuchtet wenn Gang 0 eingelegt und Zündschlüssel steckt )
an Ausgang "Neutrallampe" anhängen
Neutrallampe für eigene Ganganzeige
Externe Beschaltung
Anzeige:
nicht bestückt
rising edge trigger A
BAR
RES
BL resistors
Standard panel Fiducial
panel Fiducial with solder mask around fiducial
non retriggerable
retriggerable

Schematic: BEP33_12panel stencil.sch, sheet 11

Parts:
6V8, 10V8: TPSB2.0; B2.0
17, 18: 2081-1132; 12-PIN
C87, C88: 100u; C1206
C89, C96: 100nF,; C0805
C90, C97: 4.7u; C0805
C91, C92: 100nF.; C0805
C93: 2.2nF; C0805
C94, C95: 100nF; C0805
C98: 10u; C1206
D95, D96: 1N4007,; DO-214AC
D97, D111: 1N4007.; DO-214AC
D98, D104: 1N5817; DO-214AC_SLIM
D99, D100: 1N5817.; DO-214AC_SLIM
D113: 1N4007; DO-214AC
D114: Zen15; DO214AA
D115, D116: SS12; DO-214AC_SLIM
D117: Zen11; SOD-123_MINI-SMA
FID33, FID34, FID35, FID36: FIDUCIAL; FIDUCIAL_1MM
IC64: 4028; SO16
IC65: 317TO202H_NOHOLE; TO220H_NOHOLE
IC66: ULN2004; SO16
IC67: LM339; SO14
IC68: 78L06; SOT89_ROUND
IC69: 555; SO08
IC70: 4538; SO16
IC71: 78L10; SOT89_ROUND
IC72: LM2904; SO08
JP36, JP38, JP39, JP40: JP2EJP2_SMALLPADS; JP2_SMALLPADS
JP37: JP2E_ORIG; JP2_ORIG_SMALLPADS
LED43, LED44, LED45, LED46, LED47, LED48: LEDLD260; LD260
Q74, Q77, Q82: BA; SOT89
Q75, Q76: BA.; SOT89
Q78: MY; SOT89
Q79, Q80, Q81, Q83: J1; SOT-23
R409, R411, R438, R439: 47; V235/17_1MM
R410, R430, R431, R452, R455: 13; R1206
R412, R413, R414, R419, R420, R435, R436, R449, R450, R451, R457: 104; R0805
R415, R425, R433, R456: 4701; R0805
R416, R417, R422, R424, R442, R443, R446, R447: 1002; R0805
R418, R421: 1502; R0805
R423, R441, R453: 2201; R0805
R426, R432, R437, R440, R445: 2702; R0805
R427, R428, R429, R444: 102; R0805
R434, R454, R458, R459: 100; R0805
R448: R_user; R0805
SJMP8: SJ
START8: TPSB2.0; B2.0
TP185, TP186, TP187, TP188, TP189, TP190, TP191, TP192, TP193, TP194, TP195, TP196, TP197, TP198, TP199, TP200, TP201, TP202, TP204, TP205, TP206, TP207: TPSB2.0; B2.0
TP203: TPSB1,27; B1,27
X22: CON_BMWV2; 24-PIN_V2
X23: 22-23-2051
X24: 22-23-2021

Connections:
+10V: 10V8.TP, C94.1, IC69.4 (R), IC69.8 (V+), IC70.3 (CD), IC70.5 (B), IC70.13 (CD), IC70.16 (VDD), IC71.1 (OUT), R440.2, R457.2; also elsewhere on the board
+12V: 18.1, C98.1, D114.C, IC64.16 (VDD), IC66.9 (CD+), IC68.3 (IN), IC71.3 (IN), JP36.2, R412.2, R413.2, R414.2, R430.1, R431.1, R435.1, R458.2, R459.2, TP206.TP, X23.1; also elsewhere on the board
+12V9: 18.11, Q78.2 (C), R441.1, TP205.TP
GND: 17.12, C87.2, C88.2, C89.2, C90.2, C91.2, C92.1, C93.1, C94.2, C95.2, C96.2, C97.1, C98.2, D111.1 (+), D114.A, D117.A, IC64.8 (VSS), IC64.11 (D), IC66.8 (GND), IC67.12 (GND), IC68.2 (GND), IC68.2@1 (GND), IC69.1 (GND), IC70.1 (T1), IC70.8 (VSS), IC70.15 (T1), IC71.2 (GND), IC71.2@1 (GND), IC72.4 (V-), Q79.2 (S), Q81.2 (S), Q83.2 (S), R416.1, R422.1, R426.1, R427.2, R436.2, R438.1, R439.1, R447.1, R448.2, R452.2, R453.2, R454.1, X22.13, X22.18, X22.23, X23.5, X24.1; also elsewhere on the board
unnamed: R409.2, R411.1
unnamed: 18.9, D98.1 (+), D99.1 (+), JP38.1, JP39.2, TP203.TP
unnamed: IC64.10 (A), R414.1, R451.1, R451.2, X22.4, X23.2
unnamed: IC64.13 (B), R413.1, R450.1, R450.2, X22.3, X23.3
unnamed: D111.2 (-), Q74.2 (C), START8.TP, X22.5
unnamed: IC64.12 (C), R412.1, R449.1, R449.2, X22.2, X23.4
unnamed: 18.7, LED47.A, TP201.TP, X22.8
unnamed: 18.2, D100.2 (-), LED43.K (C), TP196.TP, X22.12
unnamed: 18.3, D99.2 (-), LED44.K (C), TP197.TP, X22.11
unnamed: 18.4, D98.2 (-), LED45.K (C), TP198.TP, X22.10
unnamed: 18.8, D104.2 (-), LED48.K (C), TP202.TP, X22.14
unnamed: 17.9, D95.1 (+), TP193.TP, X22.17
unnamed: 17.11, D96.1 (+), TP195.TP, X22.19
unnamed: R415.2, X22.22
unnamed: C90.1, IC72.3 (+IN), R415.1
unnamed: IC67.1 (OUT), R419.2, R424.2
unnamed: C87.1, R419.1, R420.2
unnamed: C88.1, IC67.4 (-IN), IC67.10 (-IN), R420.1
unnamed: IC67.5 (+IN), IC67.11 (+IN), R421.1, R422.2, R423.2
unnamed: C91.1, IC67.9 (+IN), R426.2, R432.2
unnamed: C92.2, IC67.14 (OUT), R425.2
unnamed: Q77.1 (B), R425.1
unnamed: IC64.2 (Q2), IC66.7 (I7)
unnamed: 17.5, IC66.12 (O5), TP189.TP
unnamed: IC64.1 (Q4), IC66.4 (I4)
unnamed: 18.10, TP204.TP, X22.15
unnamed: 18.5, D97.2 (-), LED46.K (C), TP199.TP, X22.9
unnamed: D97.1 (+), R409.1
unnamed: IC64.6 (Q5), IC66.3 (I3)
unnamed: 17.4, IC66.10 (O7), TP188.TP
unnamed: IC65.1 (ADJ), R410.1, R417.2, X22.7
unnamed: IC67.6 (-IN), IC67.8 (-IN), R417.1
unnamed: 17.2, Q76.2 (C), TP186.TP
unnamed: 17.1, D116.2 (-), TP185.TP
unnamed: R437.2, X22.16
unnamed: IC64.15 (Q3), IC66.5 (I5)
unnamed: 17.6, IC66.13 (O4), TP190.TP
unnamed: 17.7, IC66.14 (O3), TP191.TP
unnamed: 18.6, JP37.2, TP200.TP
unnamed: LED43.A, LED44.A, LED45.A, LED46.A, LED48.A
unnamed: Q74.1 (B), R429.2
unnamed: IC64.3 (Q0), IC66.1 (I1), IC66.2 (I2), Q80.1 (G), Q81.1 (G)
unnamed: IC64.14 (Q1), IC66.6 (I6)
unnamed: 17.3, IC66.11 (O6), TP187.TP
unnamed: Q75.1 (B), Q75.2 (C), Q76.1 (B), R427.1, R448.1, X24.2
unnamed: Q76.3 (E), R431.2
unnamed: Q75.3 (E), R430.2
unnamed: IC67.7 (+IN), R418.1, R432.1
unnamed: IC72.2 (-IN), R416.2
unnamed: Q78.1 (B), R433.2, R453.1
unnamed: Q79.3 (D), R434.2
unnamed: IC65.2 (VO), R410.2
unnamed: IC65.3 (VI), Q77.2 (C)
unnamed: IC69.3 (Q), IC70.4 (A), IC70.12 (A)
unnamed: D113.1 (+), R437.1
unnamed: 17.10, D95.2 (-), D96.2 (-), JP40.1, TP194.TP
unnamed: JP40.2, R438.2, R439.2
unnamed: IC70.9 (!Q), IC70.11 (B), R442.2
unnamed: C95.1, IC70.14 (T2), R440.1
unnamed: JP36.1, R441.2
unnamed: IC66.15 (O2), R429.1
unnamed: 18.12, R442.1, TP207.TP
unnamed: D100.1 (+), JP38.2
unnamed: IC72.1 (OUT), R443.2
unnamed: C96.1, R443.1, R444.1
unnamed: IC72.5 (+IN), Q81.3 (D), R444.2, R445.2
unnamed: IC72.6 (-IN), R446.1, R447.2
unnamed: D104.1 (+), JP39.1
unnamed: JP37.3, R434.1
unnamed: IC67.13 (OUT), JP37.1, Q79.1 (G), R435.2
unnamed: R428.1, X22.21
unnamed: IC66.16 (O1), Q80.3 (D), R455.1
unnamed: D115.2 (-), R458.1, R459.1
unnamed: 17.8, R455.2, TP192.TP
unnamed: Q80.2 (S), R454.2
unnamed: D116.1 (+), X22.1
unnamed: Q78.3 (E), R452.1
unnamed: C93.2, D113.2 (-), D117.C, IC69.2 (TR), IC69.6 (THR), R436.1
unnamed: Q82.1 (B), R456.1
unnamed: Q83.3 (D), R456.2
unnamed: Q82.2 (C), R411.2, SJMP8.2
unnamed: IC72.7 (OUT), R428.2, R433.1, R445.1
unnamed: IC67.2 (OUT), R423.1
unnamed: IC70.7 (!Q), Q83.1 (G)
unnamed: C97.2, IC70.2 (T2), R457.1
V+: D115.1 (+), Q74.3 (E), Q77.3 (E), Q82.3 (E), SJMP8.1, X22.6; also elsewhere on the board
VCC: 6V8.TP, C89.1, IC67.3 (V+), IC68.1 (OUT), IC72.8 (V+), R418.2, R421.2, R424.1, R446.2; also elsewhere on the board

Notes on the sheet:
6V regulated for Opamps
current source 96mA
ZündungsPlus
Zündugsplus Choke Öldrucklampe Temperaturlampe Ladekontrolllampe Tankgeber (100hm) ABS-Lampe Lampentest Warnlampe Fernlichtlampe Geschwindigkeitssignal Menütaster
DauerPlus Konstant-Strom für LEDs Gang 1 Gang 2 Gang 3 Gang 4 Gang 5 Neutrallampe Blinker rechts Blinker zusammen Blinker links Masse
DauerPlus Batterie 12V (rot weiss) Ganganzeige Signal C (gelb weiss) Ganganzeige Signal B (gelb schwarz) Ganganzeige Signal A (gelb dunkelblau) 12V/350mA zum Starknopf (schwarz grün) Zündungsplus 12V (grün schwarz) Reservelampe (weiss) ABS Leuchte (blau) Ladekontrollleuchte (schaltet auf Masse) (vi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
Masse (braun) Lampentest (schaltet auf Masse)(weiss blau) Fernlichtlampe (12V) (weiss) Drehzahl Zündspule (schwarz blau) Blinker rechts (blau scharz) Masse (braun) Blinker links (blau rot) nicht angeschlossen Tachosiganl zum Blinrelais (balu grün) Tachogeber (gelb) Masse Tachobeger (braun) Tachobel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
4.7V
Stromquelle für Gang LEDs. Für mehr als 12mA muss ein Widerstand "R_user" eingelötet werden. Für weniger muss der 1kOhm SMD Widerstand neben R_user entfernt werden I = 12V/1kOhm(default)+12V/R_user I= 12mA (default) + 12V/R_user Beispiel: R_user Strom in LEDs 1 kOhm 22-26mA ohne 11-13mA
Gang 1
Gang 2
Gang 3
Gang 4
Gang 5
Variante "eine LED leuchtet"
Variante "alle LEDs bis und mit Gang X leuchten"
Klemmleisten Ausgang:
Klemmleisten Ausgang:
an Zündungsplus anhängen (Neutral leuchtet wenn Gang 0 eingelegt und Zündschlüssel steckt )
an Ausgang "Neutrallampe" anhängen
Neutrallampe für eigene Ganganzeige
Externe Beschaltung
Anzeige:
nicht bestückt
rising edge trigger A
BAR
RES
BL resistors
Standard panel Fiducial
panel Fiducial with solder mask around fiducial
non retriggerable
retriggerable

Schematic: BEP33_12panel stencil.sch, sheet 12

Parts:
6V9, 10V9: TPSB2.0; B2.0
19, 20: 2081-1132; 12-PIN
C99, C100: 100u; C1206
C111, C118: 100nF,; C0805
C112, C119: 4.7u; C0805
C113, C114: 100nF.; C0805
C115: 2.2nF; C0805
C116, C117: 100nF; C0805
C120: 10u; C1206
D118, D119: 1N4007,; DO-214AC
D120, D125: 1N4007.; DO-214AC
D121, D124: 1N5817; DO-214AC_SLIM
D122, D123: 1N5817.; DO-214AC_SLIM
D126: 1N4007; DO-214AC
D127: Zen15; DO214AA
D128, D129: SS12; DO-214AC_SLIM
D130: Zen11; SOD-123_MINI-SMA
FID37, FID38, FID39, FID40: FIDUCIAL; FIDUCIAL_1MM
IC73: 4028; SO16
IC74: 317TO202H_NOHOLE; TO220H_NOHOLE
IC75: ULN2004; SO16
IC76: LM339; SO14
IC77: 78L06; SOT89_ROUND
IC78: 555; SO08
IC79: 4538; SO16
IC80: 78L10; SOT89_ROUND
IC81: LM2904; SO08
JP41, JP43, JP44, JP45: JP2EJP2_SMALLPADS; JP2_SMALLPADS
JP42: JP2E_ORIG; JP2_ORIG_SMALLPADS
LED49, LED50, LED51, LED52, LED53, LED54: LEDLD260; LD260
Q84, Q87, Q92: BA; SOT89
Q85, Q86: BA.; SOT89
Q88: MY; SOT89
Q89, Q90, Q91, Q93: J1; SOT-23
R460, R462, R489, R490: 47; V235/17_1MM
R461, R481, R482, R503, R506: 13; R1206
R463, R464, R465, R470, R471, R486, R487, R500, R501, R502, R508: 104; R0805
R466, R476, R484, R507: 4701; R0805
R467, R468, R473, R475, R493, R494, R497, R498: 1002; R0805
R469, R472: 1502; R0805
R474, R492, R504: 2201; R0805
R477, R483, R488, R491, R496: 2702; R0805
R478, R479, R480, R495: 102; R0805
R485, R505, R509, R510: 100; R0805
R499: R_user; R0805
SJMP9: SJ
START9: TPSB2.0; B2.0
TP208, TP209, TP210, TP211, TP212, TP213, TP214, TP215, TP216, TP217, TP218, TP219, TP220, TP221, TP222, TP223, TP224, TP225, TP227, TP228, TP229, TP230: TPSB2.0; B2.0
TP226: TPSB1,27; B1,27
X25: CON_BMWV2; 24-PIN_V2
X26: 22-23-2051
X27: 22-23-2021

Connections:
+10V: 10V9.TP, C116.1, IC78.4 (R), IC78.8 (V+), IC79.3 (CD), IC79.5 (B), IC79.13 (CD), IC79.16 (VDD), IC80.1 (OUT), R491.2, R508.2; also elsewhere on the board
+12V: 20.1, C120.1, D127.C, IC73.16 (VDD), IC75.9 (CD+), IC77.3 (IN), IC80.3 (IN), JP41.2, R463.2, R464.2, R465.2, R481.1, R482.1, R486.1, R509.2, R510.2, TP229.TP, X26.1; also elsewhere on the board
+12V10: 20.11, Q88.2 (C), R492.1, TP228.TP
GND: 19.12, C99.2, C100.2, C111.2, C112.2, C113.2, C114.1, C115.1, C116.2, C117.2, C118.2, C119.1, C120.2, D125.1 (+), D127.A, D130.A, IC73.8 (VSS), IC73.11 (D), IC75.8 (GND), IC76.12 (GND), IC77.2 (GND), IC77.2@1 (GND), IC78.1 (GND), IC79.1 (T1), IC79.8 (VSS), IC79.15 (T1), IC80.2 (GND), IC80.2@1 (GND), IC81.4 (V-), Q89.2 (S), Q91.2 (S), Q93.2 (S), R467.1, R473.1, R477.1, R478.2, R487.2, R489.1, R490.1, R498.1, R499.2, R503.2, R504.2, R505.1, X25.13, X25.18, X25.23, X26.5, X27.1; also elsewhere on the board
unnamed: R460.2, R462.1
unnamed: 20.9, D121.1 (+), D122.1 (+), JP43.1, JP44.2, TP226.TP
unnamed: IC73.10 (A), R465.1, R502.1, R502.2, X25.4, X26.2
unnamed: IC73.13 (B), R464.1, R501.1, R501.2, X25.3, X26.3
unnamed: D125.2 (-), Q84.2 (C), START9.TP, X25.5
unnamed: IC73.12 (C), R463.1, R500.1, R500.2, X25.2, X26.4
unnamed: 20.7, LED53.A, TP224.TP, X25.8
unnamed: 20.2, D123.2 (-), LED49.K (C), TP219.TP, X25.12
unnamed: 20.3, D122.2 (-), LED50.K (C), TP220.TP, X25.11
unnamed: 20.4, D121.2 (-), LED51.K (C), TP221.TP, X25.10
unnamed: 20.8, D124.2 (-), LED54.K (C), TP225.TP, X25.14
unnamed: 19.9, D118.1 (+), TP216.TP, X25.17
unnamed: 19.11, D119.1 (+), TP218.TP, X25.19
unnamed: R466.2, X25.22
unnamed: C112.1, IC81.3 (+IN), R466.1
unnamed: IC76.1 (OUT), R470.2, R475.2
unnamed: C99.1, R470.1, R471.2
unnamed: C100.1, IC76.4 (-IN), IC76.10 (-IN), R471.1
unnamed: IC76.5 (+IN), IC76.11 (+IN), R472.1, R473.2, R474.2
unnamed: C113.1, IC76.9 (+IN), R477.2, R483.2
unnamed: C114.2, IC76.14 (OUT), R476.2
unnamed: Q87.1 (B), R476.1
unnamed: IC73.2 (Q2), IC75.7 (I7)
unnamed: 19.5, IC75.12 (O5), TP212.TP
unnamed: IC73.1 (Q4), IC75.4 (I4)
unnamed: 20.10, TP227.TP, X25.15
unnamed: 20.5, D120.2 (-), LED52.K (C), TP222.TP, X25.9
unnamed: D120.1 (+), R460.1
unnamed: IC73.6 (Q5), IC75.3 (I3)
unnamed: 19.4, IC75.10 (O7), TP211.TP
unnamed: IC74.1 (ADJ), R461.1, R468.2, X25.7
unnamed: IC76.6 (-IN), IC76.8 (-IN), R468.1
unnamed: 19.2, Q86.2 (C), TP209.TP
unnamed: 19.1, D129.2 (-), TP208.TP
unnamed: R488.2, X25.16
unnamed: IC73.15 (Q3), IC75.5 (I5)
unnamed: 19.6, IC75.13 (O4), TP213.TP
unnamed: 19.7, IC75.14 (O3), TP214.TP
unnamed: 20.6, JP42.2, TP223.TP
unnamed: LED49.A, LED50.A, LED51.A, LED52.A, LED54.A
unnamed: Q84.1 (B), R480.2
unnamed: IC73.3 (Q0), IC75.1 (I1), IC75.2 (I2), Q90.1 (G), Q91.1 (G)
unnamed: IC73.14 (Q1), IC75.6 (I6)
unnamed: 19.3, IC75.11 (O6), TP210.TP
unnamed: Q85.1 (B), Q85.2 (C), Q86.1 (B), R478.1, R499.1, X27.2
unnamed: Q86.3 (E), R482.2
unnamed: Q85.3 (E), R481.2
unnamed: IC76.7 (+IN), R469.1, R483.1
unnamed: IC81.2 (-IN), R467.2
unnamed: Q88.1 (B), R484.2, R504.1
unnamed: Q89.3 (D), R485.2
unnamed: IC74.2 (VO), R461.2
unnamed: IC74.3 (VI), Q87.2 (C)
unnamed: IC78.3 (Q), IC79.4 (A), IC79.12 (A)
unnamed: D126.1 (+), R488.1
unnamed: 19.10, D118.2 (-), D119.2 (-), JP45.1, TP217.TP
unnamed: JP45.2, R489.2, R490.2
unnamed: IC79.9 (!Q), IC79.11 (B), R493.2
unnamed: C117.1, IC79.14 (T2), R491.1
unnamed: JP41.1, R492.2
unnamed: IC75.15 (O2), R480.1
unnamed: 20.12, R493.1, TP230.TP
unnamed: D123.1 (+), JP43.2
unnamed: IC81.1 (OUT), R494.2
unnamed: C118.1, R494.1, R495.1
unnamed: IC81.5 (+IN), Q91.3 (D), R495.2, R496.2
unnamed: IC81.6 (-IN), R497.1, R498.2
unnamed: D124.1 (+), JP44.1
unnamed: JP42.3, R485.1
unnamed: IC76.13 (OUT), JP42.1, Q89.1 (G), R486.2
unnamed: R479.1, X25.21
unnamed: IC75.16 (O1), Q90.3 (D), R506.1
unnamed: D128.2 (-), R509.1, R510.1
unnamed: 19.8, R506.2, TP215.TP
unnamed: Q90.2 (S), R505.2
unnamed: D129.1 (+), X25.1
unnamed: Q88.3 (E), R503.1
unnamed: C115.2, D126.2 (-), D130.C, IC78.2 (TR), IC78.6 (THR), R487.1
unnamed: Q92.1 (B), R507.1
unnamed: Q93.3 (D), R507.2
unnamed: Q92.2 (C), R462.2, SJMP9.2
unnamed: IC81.7 (OUT), R479.2, R484.1, R496.1
unnamed: IC76.2 (OUT), R474.1
unnamed: IC79.7 (!Q), Q93.1 (G)
unnamed: C119.2, IC79.2 (T2), R508.1
V+: D128.1 (+), Q84.3 (E), Q87.3 (E), Q92.3 (E), SJMP9.1, X25.6; also elsewhere on the board
VCC: 6V9.TP, C111.1, IC76.3 (V+), IC77.1 (OUT), IC81.8 (V+), R469.2, R472.2, R475.1, R497.2; also elsewhere on the board

Notes on the sheet:
6V regulated for Opamps
current source 96mA
ZündungsPlus
Zündugsplus Choke Öldrucklampe Temperaturlampe Ladekontrolllampe Tankgeber (100hm) ABS-Lampe Lampentest Warnlampe Fernlichtlampe Geschwindigkeitssignal Menütaster
DauerPlus Konstant-Strom für LEDs Gang 1 Gang 2 Gang 3 Gang 4 Gang 5 Neutrallampe Blinker rechts Blinker zusammen Blinker links Masse
DauerPlus Batterie 12V (rot weiss) Ganganzeige Signal C (gelb weiss) Ganganzeige Signal B (gelb schwarz) Ganganzeige Signal A (gelb dunkelblau) 12V/350mA zum Starknopf (schwarz grün) Zündungsplus 12V (grün schwarz) Reservelampe (weiss) ABS Leuchte (blau) Ladekontrollleuchte (schaltet auf Masse) (vi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
Masse (braun) Lampentest (schaltet auf Masse)(weiss blau) Fernlichtlampe (12V) (weiss) Drehzahl Zündspule (schwarz blau) Blinker rechts (blau scharz) Masse (braun) Blinker links (blau rot) nicht angeschlossen Tachosiganl zum Blinrelais (balu grün) Tachogeber (gelb) Masse Tachobeger (braun) Tachobel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
4.7V
Stromquelle für Gang LEDs. Für mehr als 12mA muss ein Widerstand "R_user" eingelötet werden. Für weniger muss der 1kOhm SMD Widerstand neben R_user entfernt werden I = 12V/1kOhm(default)+12V/R_user I= 12mA (default) + 12V/R_user Beispiel: R_user Strom in LEDs 1 kOhm 22-26mA ohne 11-13mA
Gang 1
Gang 2
Gang 3
Gang 4
Gang 5
Variante "eine LED leuchtet"
Variante "alle LEDs bis und mit Gang X leuchten"
Klemmleisten Ausgang:
Klemmleisten Ausgang:
an Zündungsplus anhängen (Neutral leuchtet wenn Gang 0 eingelegt und Zündschlüssel steckt )
an Ausgang "Neutrallampe" anhängen
Neutrallampe für eigene Ganganzeige
Externe Beschaltung
Anzeige:
nicht bestückt
rising edge trigger A
BAR
RES
BL resistors
Standard panel Fiducial
panel Fiducial with solder mask around fiducial
non retriggerable
retriggerable

Schematic: BEP33_12panel stencil.sch, sheet 13

Parts:
6V10, 10V10: TPSB2.0; B2.0
21, 22: 2081-1132; 12-PIN
C121, C122: 100u; C1206
C123, C130: 100nF,; C0805
C124, C131: 4.7u; C0805
C125, C126: 100nF.; C0805
C127: 2.2nF; C0805
C128, C129: 100nF; C0805
C132: 10u; C1206
D131, D132: 1N4007,; DO-214AC
D133, D138: 1N4007.; DO-214AC
D134, D137: 1N5817; DO-214AC_SLIM
D135, D136: 1N5817.; DO-214AC_SLIM
D139: 1N4007; DO-214AC
D140: Zen15; DO214AA
D141, D142: SS12; DO-214AC_SLIM
D143: Zen11; SOD-123_MINI-SMA
FID41, FID42, FID43, FID44: FIDUCIAL; FIDUCIAL_1MM
IC82: 4028; SO16
IC83: 317TO202H_NOHOLE; TO220H_NOHOLE
IC84: ULN2004; SO16
IC85: LM339; SO14
IC86: 78L06; SOT89_ROUND
IC87: 555; SO08
IC88: 4538; SO16
IC89: 78L10; SOT89_ROUND
IC90: LM2904; SO08
JP46, JP48, JP49, JP50: JP2EJP2_SMALLPADS; JP2_SMALLPADS
JP47: JP2E_ORIG; JP2_ORIG_SMALLPADS
LED55, LED56, LED57, LED58, LED59, LED60: LEDLD260; LD260
Q94, Q97, Q109: BA; SOT89
Q95, Q96: BA.; SOT89
Q98: MY; SOT89
Q99, Q100, Q108, Q110: J1; SOT-23
R511, R513, R540, R541: 47; V235/17_1MM
R512, R532, R533, R554, R557: 13; R1206
R514, R515, R516, R521, R522, R537, R538, R551, R552, R553, R559: 104; R0805
R517, R527, R535, R558: 4701; R0805
R518, R519, R524, R526, R544, R545, R548, R549: 1002; R0805
R520, R523: 1502; R0805
R525, R543, R555: 2201; R0805
R528, R534, R539, R542, R547: 2702; R0805
R529, R530, R531, R546: 102; R0805
R536, R556, R560, R561: 100; R0805
R550: R_user; R0805
SJMP10: SJ
START10: TPSB2.0; B2.0
TP231, TP232, TP233, TP234, TP235, TP236, TP237, TP238, TP239, TP240, TP241, TP242, TP243, TP244, TP245, TP246, TP247, TP248, TP250, TP251, TP252, TP253: TPSB2.0; B2.0
TP249: TPSB1,27; B1,27
X28: CON_BMWV2; 24-PIN_V2
X29: 22-23-2051
X30: 22-23-2021

Connections:
+10V: 10V10.TP, C128.1, IC87.4 (R), IC87.8 (V+), IC88.3 (CD), IC88.5 (B), IC88.13 (CD), IC88.16 (VDD), IC89.1 (OUT), R542.2, R559.2; also elsewhere on the board
+12V: 22.1, C132.1, D140.C, IC82.16 (VDD), IC84.9 (CD+), IC86.3 (IN), IC89.3 (IN), JP46.2, R514.2, R515.2, R516.2, R532.1, R533.1, R537.1, R560.2, R561.2, TP252.TP, X29.1; also elsewhere on the board
+12V11: 22.11, Q98.2 (C), R543.1, TP251.TP
GND: 21.12, C121.2, C122.2, C123.2, C124.2, C125.2, C126.1, C127.1, C128.2, C129.2, C130.2, C131.1, C132.2, D138.1 (+), D140.A, D143.A, IC82.8 (VSS), IC82.11 (D), IC84.8 (GND), IC85.12 (GND), IC86.2 (GND), IC86.2@1 (GND), IC87.1 (GND), IC88.1 (T1), IC88.8 (VSS), IC88.15 (T1), IC89.2 (GND), IC89.2@1 (GND), IC90.4 (V-), Q99.2 (S), Q108.2 (S), Q110.2 (S), R518.1, R524.1, R528.1, R529.2, R538.2, R540.1, R541.1, R549.1, R550.2, R554.2, R555.2, R556.1, X28.13, X28.18, X28.23, X29.5, X30.1; also elsewhere on the board
unnamed: R511.2, R513.1
unnamed: 22.9, D134.1 (+), D135.1 (+), JP48.1, JP49.2, TP249.TP
unnamed: IC82.10 (A), R516.1, R553.1, R553.2, X28.4, X29.2
unnamed: IC82.13 (B), R515.1, R552.1, R552.2, X28.3, X29.3
unnamed: D138.2 (-), Q94.2 (C), START10.TP, X28.5
unnamed: IC82.12 (C), R514.1, R551.1, R551.2, X28.2, X29.4
unnamed: 22.7, LED59.A, TP247.TP, X28.8
unnamed: 22.2, D136.2 (-), LED55.K (C), TP242.TP, X28.12
unnamed: 22.3, D135.2 (-), LED56.K (C), TP243.TP, X28.11
unnamed: 22.4, D134.2 (-), LED57.K (C), TP244.TP, X28.10
unnamed: 22.8, D137.2 (-), LED60.K (C), TP248.TP, X28.14
unnamed: 21.9, D131.1 (+), TP239.TP, X28.17
unnamed: 21.11, D132.1 (+), TP241.TP, X28.19
unnamed: R517.2, X28.22
unnamed: C124.1, IC90.3 (+IN), R517.1
unnamed: IC85.1 (OUT), R521.2, R526.2
unnamed: C121.1, R521.1, R522.2
unnamed: C122.1, IC85.4 (-IN), IC85.10 (-IN), R522.1
unnamed: IC85.5 (+IN), IC85.11 (+IN), R523.1, R524.2, R525.2
unnamed: C125.1, IC85.9 (+IN), R528.2, R534.2
unnamed: C126.2, IC85.14 (OUT), R527.2
unnamed: Q97.1 (B), R527.1
unnamed: IC82.2 (Q2), IC84.7 (I7)
unnamed: 21.5, IC84.12 (O5), TP235.TP
unnamed: IC82.1 (Q4), IC84.4 (I4)
unnamed: 22.10, TP250.TP, X28.15
unnamed: 22.5, D133.2 (-), LED58.K (C), TP245.TP, X28.9
unnamed: D133.1 (+), R511.1
unnamed: IC82.6 (Q5), IC84.3 (I3)
unnamed: 21.4, IC84.10 (O7), TP234.TP
unnamed: IC83.1 (ADJ), R512.1, R519.2, X28.7
unnamed: IC85.6 (-IN), IC85.8 (-IN), R519.1
unnamed: 21.2, Q96.2 (C), TP232.TP
unnamed: 21.1, D142.2 (-), TP231.TP
unnamed: R539.2, X28.16
unnamed: IC82.15 (Q3), IC84.5 (I5)
unnamed: 21.6, IC84.13 (O4), TP236.TP
unnamed: 21.7, IC84.14 (O3), TP237.TP
unnamed: 22.6, JP47.2, TP246.TP
unnamed: LED55.A, LED56.A, LED57.A, LED58.A, LED60.A
unnamed: Q94.1 (B), R531.2
unnamed: IC82.3 (Q0), IC84.1 (I1), IC84.2 (I2), Q100.1 (G), Q108.1 (G)
unnamed: IC82.14 (Q1), IC84.6 (I6)
unnamed: 21.3, IC84.11 (O6), TP233.TP
unnamed: Q95.1 (B), Q95.2 (C), Q96.1 (B), R529.1, R550.1, X30.2
unnamed: Q96.3 (E), R533.2
unnamed: Q95.3 (E), R532.2
unnamed: IC85.7 (+IN), R520.1, R534.1
unnamed: IC90.2 (-IN), R518.2
unnamed: Q98.1 (B), R535.2, R555.1
unnamed: Q99.3 (D), R536.2
unnamed: IC83.2 (VO), R512.2
unnamed: IC83.3 (VI), Q97.2 (C)
unnamed: IC87.3 (Q), IC88.4 (A), IC88.12 (A)
unnamed: D139.1 (+), R539.1
unnamed: 21.10, D131.2 (-), D132.2 (-), JP50.1, TP240.TP
unnamed: JP50.2, R540.2, R541.2
unnamed: IC88.9 (!Q), IC88.11 (B), R544.2
unnamed: C129.1, IC88.14 (T2), R542.1
unnamed: JP46.1, R543.2
unnamed: IC84.15 (O2), R531.1
unnamed: 22.12, R544.1, TP253.TP
unnamed: D136.1 (+), JP48.2
unnamed: IC90.1 (OUT), R545.2
unnamed: C130.1, R545.1, R546.1
unnamed: IC90.5 (+IN), Q108.3 (D), R546.2, R547.2
unnamed: IC90.6 (-IN), R548.1, R549.2
unnamed: D137.1 (+), JP49.1
unnamed: JP47.3, R536.1
unnamed: IC85.13 (OUT), JP47.1, Q99.1 (G), R537.2
unnamed: R530.1, X28.21
unnamed: IC84.16 (O1), Q100.3 (D), R557.1
unnamed: D141.2 (-), R560.1, R561.1
unnamed: 21.8, R557.2, TP238.TP
unnamed: Q100.2 (S), R556.2
unnamed: D142.1 (+), X28.1
unnamed: Q98.3 (E), R554.1
unnamed: C127.2, D139.2 (-), D143.C, IC87.2 (TR), IC87.6 (THR), R538.1
unnamed: Q109.1 (B), R558.1
unnamed: Q110.3 (D), R558.2
unnamed: Q109.2 (C), R513.2, SJMP10.2
unnamed: IC90.7 (OUT), R530.2, R535.1, R547.1
unnamed: IC85.2 (OUT), R525.1
unnamed: IC88.7 (!Q), Q110.1 (G)
unnamed: C131.2, IC88.2 (T2), R559.1
V+: D141.1 (+), Q94.3 (E), Q97.3 (E), Q109.3 (E), SJMP10.1, X28.6; also elsewhere on the board
VCC: 6V10.TP, C123.1, IC85.3 (V+), IC86.1 (OUT), IC90.8 (V+), R520.2, R523.2, R526.1, R548.2; also elsewhere on the board

Notes on the sheet:
6V regulated for Opamps
current source 96mA
ZündungsPlus
Zündugsplus Choke Öldrucklampe Temperaturlampe Ladekontrolllampe Tankgeber (100hm) ABS-Lampe Lampentest Warnlampe Fernlichtlampe Geschwindigkeitssignal Menütaster
DauerPlus Konstant-Strom für LEDs Gang 1 Gang 2 Gang 3 Gang 4 Gang 5 Neutrallampe Blinker rechts Blinker zusammen Blinker links Masse
DauerPlus Batterie 12V (rot weiss) Ganganzeige Signal C (gelb weiss) Ganganzeige Signal B (gelb schwarz) Ganganzeige Signal A (gelb dunkelblau) 12V/350mA zum Starknopf (schwarz grün) Zündungsplus 12V (grün schwarz) Reservelampe (weiss) ABS Leuchte (blau) Ladekontrollleuchte (schaltet auf Masse) (vi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
Masse (braun) Lampentest (schaltet auf Masse)(weiss blau) Fernlichtlampe (12V) (weiss) Drehzahl Zündspule (schwarz blau) Blinker rechts (blau scharz) Masse (braun) Blinker links (blau rot) nicht angeschlossen Tachosiganl zum Blinrelais (balu grün) Tachogeber (gelb) Masse Tachobeger (braun) Tachobel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
4.7V
Stromquelle für Gang LEDs. Für mehr als 12mA muss ein Widerstand "R_user" eingelötet werden. Für weniger muss der 1kOhm SMD Widerstand neben R_user entfernt werden I = 12V/1kOhm(default)+12V/R_user I= 12mA (default) + 12V/R_user Beispiel: R_user Strom in LEDs 1 kOhm 22-26mA ohne 11-13mA
Gang 1
Gang 2
Gang 3
Gang 4
Gang 5
Variante "eine LED leuchtet"
Variante "alle LEDs bis und mit Gang X leuchten"
Klemmleisten Ausgang:
Klemmleisten Ausgang:
an Zündungsplus anhängen (Neutral leuchtet wenn Gang 0 eingelegt und Zündschlüssel steckt )
an Ausgang "Neutrallampe" anhängen
Neutrallampe für eigene Ganganzeige
Externe Beschaltung
Anzeige:
nicht bestückt
rising edge trigger A
BAR
RES
BL resistors
Standard panel Fiducial
panel Fiducial with solder mask around fiducial
non retriggerable
retriggerable

Schematic: BEP33_12panel stencil.sch, sheet 14

Parts:
6V11, 10V11: TPSB2.0; B2.0
23, 24: 2081-1132; 12-PIN
C133, C134: 100u; C1206
C135, C142: 100nF,; C0805
C136, C143: 4.7u; C0805
C137, C138: 100nF.; C0805
C139: 2.2nF; C0805
C140, C141: 100nF; C0805
C144: 10u; C1206
D144, D145: 1N4007,; DO-214AC
D146, D151: 1N4007.; DO-214AC
D147, D150: 1N5817; DO-214AC_SLIM
D148, D149: 1N5817.; DO-214AC_SLIM
D152: 1N4007; DO-214AC
D153: Zen15; DO214AA
D154, D155: SS12; DO-214AC_SLIM
D156: Zen11; SOD-123_MINI-SMA
FID45, FID46, FID47, FID48: FIDUCIAL; FIDUCIAL_1MM
IC91: 4028; SO16
IC92: 317TO202H_NOHOLE; TO220H_NOHOLE
IC93: ULN2004; SO16
IC94: LM339; SO14
IC95: 78L06; SOT89_ROUND
IC96: 555; SO08
IC97: 4538; SO16
IC98: 78L10; SOT89_ROUND
IC99: LM2904; SO08
JP51, JP53, JP54, JP55: JP2EJP2_SMALLPADS; JP2_SMALLPADS
JP52: JP2E_ORIG; JP2_ORIG_SMALLPADS
LED61, LED62, LED63, LED64, LED65, LED66: LEDLD260; LD260
Q111, Q114, Q119: BA; SOT89
Q112, Q113: BA.; SOT89
Q115: MY; SOT89
Q116, Q117, Q118, Q120: J1; SOT-23
R562, R564, R591, R592: 47; V235/17_1MM
R563, R583, R584, R605, R608: 13; R1206
R565, R566, R567, R572, R573, R588, R589, R602, R603, R604, R610: 104; R0805
R568, R578, R586, R609: 4701; R0805
R569, R570, R575, R577, R595, R596, R599, R600: 1002; R0805
R571, R574: 1502; R0805
R576, R594, R606: 2201; R0805
R579, R585, R590, R593, R598: 2702; R0805
R580, R581, R582, R597: 102; R0805
R587, R607, R611, R612: 100; R0805
R601: R_user; R0805
SJMP11: SJ
START11: TPSB2.0; B2.0
TP254, TP255, TP256, TP257, TP258, TP259, TP260, TP261, TP262, TP263, TP264, TP265, TP266, TP267, TP268, TP269, TP270, TP271, TP273, TP274, TP275, TP276: TPSB2.0; B2.0
TP272: TPSB1,27; B1,27
X31: CON_BMWV2; 24-PIN_V2
X32: 22-23-2051
X33: 22-23-2021

Connections:
+10V: 10V11.TP, C140.1, IC96.4 (R), IC96.8 (V+), IC97.3 (CD), IC97.5 (B), IC97.13 (CD), IC97.16 (VDD), IC98.1 (OUT), R593.2, R610.2; also elsewhere on the board
+12V: 24.1, C144.1, D153.C, IC91.16 (VDD), IC93.9 (CD+), IC95.3 (IN), IC98.3 (IN), JP51.2, R565.2, R566.2, R567.2, R583.1, R584.1, R588.1, R611.2, R612.2, TP275.TP, X32.1; also elsewhere on the board
+12V12: 24.11, Q115.2 (C), R594.1, TP274.TP
GND: 23.12, C133.2, C134.2, C135.2, C136.2, C137.2, C138.1, C139.1, C140.2, C141.2, C142.2, C143.1, C144.2, D151.1 (+), D153.A, D156.A, IC91.8 (VSS), IC91.11 (D), IC93.8 (GND), IC94.12 (GND), IC95.2 (GND), IC95.2@1 (GND), IC96.1 (GND), IC97.1 (T1), IC97.8 (VSS), IC97.15 (T1), IC98.2 (GND), IC98.2@1 (GND), IC99.4 (V-), Q116.2 (S), Q118.2 (S), Q120.2 (S), R569.1, R575.1, R579.1, R580.2, R589.2, R591.1, R592.1, R600.1, R601.2, R605.2, R606.2, R607.1, X31.13, X31.18, X31.23, X32.5, X33.1; also elsewhere on the board
unnamed: R562.2, R564.1
unnamed: 24.9, D147.1 (+), D148.1 (+), JP53.1, JP54.2, TP272.TP
unnamed: IC91.10 (A), R567.1, R604.1, R604.2, X31.4, X32.2
unnamed: IC91.13 (B), R566.1, R603.1, R603.2, X31.3, X32.3
unnamed: D151.2 (-), Q111.2 (C), START11.TP, X31.5
unnamed: IC91.12 (C), R565.1, R602.1, R602.2, X31.2, X32.4
unnamed: 24.7, LED65.A, TP270.TP, X31.8
unnamed: 24.2, D149.2 (-), LED61.K (C), TP265.TP, X31.12
unnamed: 24.3, D148.2 (-), LED62.K (C), TP266.TP, X31.11
unnamed: 24.4, D147.2 (-), LED63.K (C), TP267.TP, X31.10
unnamed: 24.8, D150.2 (-), LED66.K (C), TP271.TP, X31.14
unnamed: 23.9, D144.1 (+), TP262.TP, X31.17
unnamed: 23.11, D145.1 (+), TP264.TP, X31.19
unnamed: R568.2, X31.22
unnamed: C136.1, IC99.3 (+IN), R568.1
unnamed: IC94.1 (OUT), R572.2, R577.2
unnamed: C133.1, R572.1, R573.2
unnamed: C134.1, IC94.4 (-IN), IC94.10 (-IN), R573.1
unnamed: IC94.5 (+IN), IC94.11 (+IN), R574.1, R575.2, R576.2
unnamed: C137.1, IC94.9 (+IN), R579.2, R585.2
unnamed: C138.2, IC94.14 (OUT), R578.2
unnamed: Q114.1 (B), R578.1
unnamed: IC91.2 (Q2), IC93.7 (I7)
unnamed: 23.5, IC93.12 (O5), TP258.TP
unnamed: IC91.1 (Q4), IC93.4 (I4)
unnamed: 24.10, TP273.TP, X31.15
unnamed: 24.5, D146.2 (-), LED64.K (C), TP268.TP, X31.9
unnamed: D146.1 (+), R562.1
unnamed: IC91.6 (Q5), IC93.3 (I3)
unnamed: 23.4, IC93.10 (O7), TP257.TP
unnamed: IC92.1 (ADJ), R563.1, R570.2, X31.7
unnamed: IC94.6 (-IN), IC94.8 (-IN), R570.1
unnamed: 23.2, Q113.2 (C), TP255.TP
unnamed: 23.1, D155.2 (-), TP254.TP
unnamed: R590.2, X31.16
unnamed: IC91.15 (Q3), IC93.5 (I5)
unnamed: 23.6, IC93.13 (O4), TP259.TP
unnamed: 23.7, IC93.14 (O3), TP260.TP
unnamed: 24.6, JP52.2, TP269.TP
unnamed: LED61.A, LED62.A, LED63.A, LED64.A, LED66.A
unnamed: Q111.1 (B), R582.2
unnamed: IC91.3 (Q0), IC93.1 (I1), IC93.2 (I2), Q117.1 (G), Q118.1 (G)
unnamed: IC91.14 (Q1), IC93.6 (I6)
unnamed: 23.3, IC93.11 (O6), TP256.TP
unnamed: Q112.1 (B), Q112.2 (C), Q113.1 (B), R580.1, R601.1, X33.2
unnamed: Q113.3 (E), R584.2
unnamed: Q112.3 (E), R583.2
unnamed: IC94.7 (+IN), R571.1, R585.1
unnamed: IC99.2 (-IN), R569.2
unnamed: Q115.1 (B), R586.2, R606.1
unnamed: Q116.3 (D), R587.2
unnamed: IC92.2 (VO), R563.2
unnamed: IC92.3 (VI), Q114.2 (C)
unnamed: IC96.3 (Q), IC97.4 (A), IC97.12 (A)
unnamed: D152.1 (+), R590.1
unnamed: 23.10, D144.2 (-), D145.2 (-), JP55.1, TP263.TP
unnamed: JP55.2, R591.2, R592.2
unnamed: IC97.9 (!Q), IC97.11 (B), R595.2
unnamed: C141.1, IC97.14 (T2), R593.1
unnamed: JP51.1, R594.2
unnamed: IC93.15 (O2), R582.1
unnamed: 24.12, R595.1, TP276.TP
unnamed: D149.1 (+), JP53.2
unnamed: IC99.1 (OUT), R596.2
unnamed: C142.1, R596.1, R597.1
unnamed: IC99.5 (+IN), Q118.3 (D), R597.2, R598.2
unnamed: IC99.6 (-IN), R599.1, R600.2
unnamed: D150.1 (+), JP54.1
unnamed: JP52.3, R587.1
unnamed: IC94.13 (OUT), JP52.1, Q116.1 (G), R588.2
unnamed: R581.1, X31.21
unnamed: IC93.16 (O1), Q117.3 (D), R608.1
unnamed: D154.2 (-), R611.1, R612.1
unnamed: 23.8, R608.2, TP261.TP
unnamed: Q117.2 (S), R607.2
unnamed: D155.1 (+), X31.1
unnamed: Q115.3 (E), R605.1
unnamed: C139.2, D152.2 (-), D156.C, IC96.2 (TR), IC96.6 (THR), R589.1
unnamed: Q119.1 (B), R609.1
unnamed: Q120.3 (D), R609.2
unnamed: Q119.2 (C), R564.2, SJMP11.2
unnamed: IC99.7 (OUT), R581.2, R586.1, R598.1
unnamed: IC94.2 (OUT), R576.1
unnamed: IC97.7 (!Q), Q120.1 (G)
unnamed: C143.2, IC97.2 (T2), R610.1
V+: D154.1 (+), Q111.3 (E), Q114.3 (E), Q119.3 (E), SJMP11.1, X31.6; also elsewhere on the board
VCC: 6V11.TP, C135.1, IC94.3 (V+), IC95.1 (OUT), IC99.8 (V+), R571.2, R574.2, R577.1, R599.2; also elsewhere on the board

Notes on the sheet:
6V regulated for Opamps
current source 96mA
ZündungsPlus
Zündugsplus Choke Öldrucklampe Temperaturlampe Ladekontrolllampe Tankgeber (100hm) ABS-Lampe Lampentest Warnlampe Fernlichtlampe Geschwindigkeitssignal Menütaster
DauerPlus Konstant-Strom für LEDs Gang 1 Gang 2 Gang 3 Gang 4 Gang 5 Neutrallampe Blinker rechts Blinker zusammen Blinker links Masse
DauerPlus Batterie 12V (rot weiss) Ganganzeige Signal C (gelb weiss) Ganganzeige Signal B (gelb schwarz) Ganganzeige Signal A (gelb dunkelblau) 12V/350mA zum Starknopf (schwarz grün) Zündungsplus 12V (grün schwarz) Reservelampe (weiss) ABS Leuchte (blau) Ladekontrollleuchte (schaltet auf Masse) (vi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
Masse (braun) Lampentest (schaltet auf Masse)(weiss blau) Fernlichtlampe (12V) (weiss) Drehzahl Zündspule (schwarz blau) Blinker rechts (blau scharz) Masse (braun) Blinker links (blau rot) nicht angeschlossen Tachosiganl zum Blinrelais (balu grün) Tachogeber (gelb) Masse Tachobeger (braun) Tachobel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
4.7V
Stromquelle für Gang LEDs. Für mehr als 12mA muss ein Widerstand "R_user" eingelötet werden. Für weniger muss der 1kOhm SMD Widerstand neben R_user entfernt werden I = 12V/1kOhm(default)+12V/R_user I= 12mA (default) + 12V/R_user Beispiel: R_user Strom in LEDs 1 kOhm 22-26mA ohne 11-13mA
Gang 1
Gang 2
Gang 3
Gang 4
Gang 5
Variante "eine LED leuchtet"
Variante "alle LEDs bis und mit Gang X leuchten"
Klemmleisten Ausgang:
Klemmleisten Ausgang:
an Zündungsplus anhängen (Neutral leuchtet wenn Gang 0 eingelegt und Zündschlüssel steckt )
an Ausgang "Neutrallampe" anhängen
Neutrallampe für eigene Ganganzeige
Externe Beschaltung
Anzeige:
nicht bestückt
rising edge trigger A
BAR
RES
BL resistors
Standard panel Fiducial
panel Fiducial with solder mask around fiducial
non retriggerable
retriggerable
